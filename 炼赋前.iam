# Autodesk Inventor assembly: 조립품
## iProperties
Created: 2015-03
Part Number: 조립품
Document SubType Name: Assembly
Designer: 102-022
Author: 102-022
